options:
  parameters:
    author: Alexandre HEUCHAMPS
    generate_options: qt_gui
    id: sweep_jammer
    output_language: python
    title: Test sweep jammer
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    value: '[f_start + i*(f_stop-f_start)/(n_channels-1) for i in range(n_channels)]'
  states: {}
- name: f_start
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: f_stop
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: n_channels
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: sweep_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: 1e4
    value: '1'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_start
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block): # other base classes are basic_block, decim_block, interp_block
          """
          Embedded Python Block
          Function changing periodically the signal source's frequency, from
          f_min to f_max, by step of BW_per_channel [i.e. (f_max-f_min)/(n_channels-1)]

          samp_rate ==> samp_rate values per signal period
          sweep_rate ==> sweep_rate cycling per second
          Means we stay samp_rate/sweep_rate values in each channel
          [N.B.: n_channels ==> samp_rate/sweep_rate/n_channels in each channel]
          """

          def __init__(self, n_channels=3, samp_rate=32e3, sweep_rate=1, f_start=2.4e3, f_stop=2.5e3): # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Frequency sweeper', # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.n_channels = n_channels
              self.samp_rate = samp_rate
              self.sweep_rate = sweep_rate
              self.f_start = f_start
              self.f_stop = f_stop

              self.BW_tot = self.f_stop - f_start

              self.frequencies = [self.f_start + i*self.BW_tot/(self.n_channels-1) for i in range(self.n_channels)]

              self.counter = 0 # if bigger than given threshold, update the frequency
              self.i = 0 # which frequency to select

              self.t_per_freq = self.samp_rate/self.sweep_rate/self.n_channels
              #self.t_per_freq = self.samp_rate/self.sweep_rate/(self.n_channels - 1)
              #self.t_per_freq = self.samp_rate/self.sweep_rate/(self.n_channels + 1)
              #self.t_per_freq = self.n_channels*self.samp_rate/(self.sweep_rate*self.n_channels + 1)

              self.outPortFreq = "frequency"
              self.message_port_register_out(pmt.intern(self.outPortFreq))
              self.outPortDebugMsg = "debug"
              self.message_port_register_out(pmt.intern(self.outPortDebugMsg))



          def work(self, input_items, output_items):
              """
              Example: change frequency of signal source periodically
              samp_rate ==> samp_rate values per signal period
              sweep_rate ==> sweep_rate cycling per second
              Means we stay samp_rate/sweep_rate values in each channel
              [N.B.: n_channels ==> samp_rate/sweep_rate/n_channels in each channel]
              """

              # Create dictionaries to send messages to source and terminal
              dict_debug = pmt.make_dict()
              dict_msg = pmt.make_dict()

              # Some debug messages sent to the terminal
              dict_debug = pmt.dict_add(dict_debug, pmt.intern("t_per_freq"), pmt.from_double(self.t_per_freq))
              dict_debug = pmt.dict_add(dict_debug, pmt.intern("counter"), pmt.from_double(self.counter))
              pmt_msg_debug = pmt.dict_add(dict_debug, pmt.intern(f"freq[{self.i}]"), pmt.from_double(self.frequencies[self.i]))
              self.message_port_pub(pmt.intern(self.outPortDebugMsg), pmt_msg_debug)

              self.counter = self.counter + len(input_items[0])

              if self.counter > self.t_per_freq:
                  self.i += 1
                  self.counter = 0

              if self.i > len(self.frequencies)-1: self.i = 0

              # Message sent to update the source frequency
              pmt_msg = pmt.dict_add(dict_msg, pmt.intern("freq"), pmt.from_double(self.frequencies[self.i]))
              self.message_port_pub(pmt.intern(self.outPortFreq), pmt_msg)

              return len(input_items[0])
    f_start: f_start
    f_stop: f_stop
    n_channels: n_channels
    samp_rate: samp_rate
    sweep_rate: sweep_rate
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The variable "samp_rate" indicates how much values are required
      to have one second elapsed
      ==> 1 second = (samp_rate) values.

      For a signal having a frequency "freq",
      	(samp_rate / freq) values
      are required to have a period.

      If the sweep frequency is given by "sweep_rate", meaning that
      the full bandwidth is swept "sweep_rate" times per second, then
      one sweep is represented by
      (1 sweep) = (samp_rate / sweep_rate) values.

      The sweep is given by
      f1 -> f2 -> ... -> fN -> f1 -> ...
      hence, "n_channels" transitions are needed. This means that we
      have the identity
      (1 sweep) = (n_channels) = (samp_rate / sweep_rate) values.
      From there, we find that we should stay at the same frequency for
      (samp_rate / sweep_rate / n_channels) values.
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '[1, 0]'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[2, 0]'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: f_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: f_signal
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', epy_block_0_0, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_1, '0', qtgui_waterfall_sink_x_1, '0']
- [epy_block_0_0, debug, blocks_message_debug_0, print]
- [epy_block_0_0, frequency, virtual_sink_0, '0']
- [virtual_source_0, '0', analog_sig_source_x_1, cmd]

metadata:
  file_format: 1
